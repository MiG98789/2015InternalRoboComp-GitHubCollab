# Keil uVision project 2015Competition.uvprojx, settings and files
target STM32f103CBT_TEMPLATE (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ROBOTICs_Hw +hex
  AfterMake: C:\Users\Miguel\Documents\Personal Items\Robotics Team\Internal Competition 2015\Code\2016_sw_ library\flash.bat .\Objects\@2015Competition.hex 5 115200 STM32F1_med-density_128K
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_ML
  c include: .\stm32f10x_std\inc;.\user
  asm include: .\stm32f10x_startup;.\stm32f10x_std;.\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stm32f103_start_up
    ./stm32f10x_startup/: startup_stm32f10x_md.s
  group stm32f103_std
    ./stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group library
    ./: LEDs.c ticks.c tft_display.c linear_ccd.c adc.c pneumatic_control.c GPIO_switch.c button.c motor.c buzzer.c buzzer_song.c uart.c servo_tutorial.c encoder.c helper.c
  group user
    ./: main.c
